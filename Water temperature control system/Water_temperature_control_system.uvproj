# Keil uVision project Water_temperature_control_system.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Water_temperature_control_system +hex
  c flags: Optimize=8 SizeSpeed=1
  group 起始代码
    ./: STARTUP.A51
  group 应用程序
    ./scr/: Uart.c main.c DS18B20.c
